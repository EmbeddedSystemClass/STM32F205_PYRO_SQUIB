# Keil uVision project PYRO_SQUIB.uvprojx, settings and files
target PYRO_SQUIB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F205RB STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: PYRO_SQUIB +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\modbus\include;..\modbus\rtu;..\modbus\port
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: PYRO_SQUIB\PYRO_SQUIB.sct
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c freertos.c adc.c cfg_info.c dig_pot.c mbinit.c pyro_squib.c usart_app.c utilities.c
  group modbus
    ../modbus/: mb.c
    ../modbus/rtu/: mbcrc.c mbrtu.c mbrtu_dma.c
    ../modbus/port/: mbport.c portevent.c portserial.c porttimer.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_rcc_ex.c stm32f2xx_hal.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_i2c.c stm32f2xx_hal_adc.c stm32f2xx_hal_uart.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_adc_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c timers.c croutine.c queue.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.1.0
